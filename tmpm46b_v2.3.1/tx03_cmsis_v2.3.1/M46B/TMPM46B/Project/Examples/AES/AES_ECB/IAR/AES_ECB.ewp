# IAR project AES_ECB.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TMPM46BF10FG Toshiba TMPM46BF10FG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG
  ICCARM.CCIncludePath2: ..\APP; ..\..\..\..\..\Libraries\TX04_CMSIS\; ..\..\..\..\..\Libraries\TX04_Periph_Driver\inc; ..\..\..\Utilities\TMPM46B-EVAL
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AES_ECB.srec
  ILINK.IlinkOutputFile: AES_ECB.out
  ILINK.IlinkIcfFile: TMPM46BF10FG_Flash_For_uDMAC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group APP
    ../APP/: aes.c aes.h main.c main.h tmpm46b_udmac_int.c tmpm46b_udmac_int.h
  group TMPM46B-EVAL
    ../../../Utilities/TMPM46B-EVAL/: common_uart.c common_uart.h
  group TX04_CMSIS
    ../../../../../Libraries/TX04_CMSIS/: system_TMPM46B.c system_TMPM46B.h TMPM46B.h
  group TX04_CMSIS/startup
    ../../../../../Libraries/TX04_CMSIS/startup/iar/: startup_TMPM46B.s
  group TX04_Periph_Driver/inc
    ../../../../../Libraries/TX04_Periph_Driver/inc/: tmpm46b_aes.h tmpm46b_gpio.h tmpm46b_uart.h tmpm46b_udmac.h TX04_common.h
  group TX04_Periph_Driver/src
    ../../../../../Libraries/TX04_Periph_Driver/src/: tmpm46b_aes.c tmpm46b_gpio.c tmpm46b_uart.c tmpm46b_udmac.c
