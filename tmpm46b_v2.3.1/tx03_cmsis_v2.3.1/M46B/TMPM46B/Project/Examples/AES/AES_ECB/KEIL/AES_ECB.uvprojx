# Keil uVision project AES_ECB.uvprojx, settings and files
target AES_ECB (ARM-ADS)
  device: TMPM46BF10FG Toshiba
  pack: Keil.TMPM4_DFP.1.1.2
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x80000) IRAM2(0x20080000,0x00800) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AES_CBC +hex
  c define: DEBUG
  c include: ..\..\..\..\..\Libraries\TX04_CMSIS;..\..\..\..\..\Libraries\TX04_Periph_Driver\inc;..\..\..\Utilities\TMPM46B-EVAL;..\APP
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  memory RVCT10: RAM 0x20080000 size 0x800
  scatter file: ..\..\..\..\Template\KEIL\tmpm46bf10.sct
  group APP
    ../APP/: aes.c tmpm46b_udmac_int.c main.c
  group TX04_CMSIS
    ../../../../../Libraries/TX04_CMSIS/: system_TMPM46B.c
    ../../../../../Libraries/TX04_CMSIS/startup/arm/: startup_TMPM46B.s
  group TX04_Periph_Driver
    ../../../../../Libraries/TX04_Periph_Driver/src/: tmpm46b_aes.c tmpm46b_uart.c tmpm46b_gpio.c tmpm46b_udmac.c
  group TMPM46B-EVAL
    ../../../Utilities/TMPM46B-EVAL/: common_uart.c
software components: CMSIS:CORE 3.40.0
