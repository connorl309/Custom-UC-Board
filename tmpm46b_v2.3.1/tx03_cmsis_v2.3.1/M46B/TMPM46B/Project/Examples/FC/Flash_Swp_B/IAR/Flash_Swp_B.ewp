# IAR project Flash_Swp_B.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TMPM46BF10FG Toshiba TMPM46BF10FG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG
  ICCARM.CCIncludePath2: ..\APP; ..\..\..\..\..\Libraries\TX04_CMSIS; ..\..\..\..\..\Libraries\TX04_Periph_Driver\inc; ..\..\..\Utilities\TMPM46B-EVAL
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Flash_Swp_B.srec
  ILINK.IlinkOutputFile: Flash_Swp_B.out
  ILINK.IlinkIcfFile: Flash_Swp_B_for_M46B.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  OBJCOPY.OOCOutputFile: Flash_Swp.srec
  group APP
    ../APP/: main.c main.h
  group TMPM46B-EVAL
    ../../../Utilities/TMPM46B-EVAL/: led.c led.h sw.c sw.h
  group TX04_CMSIS
    ../../../../../Libraries/TX04_CMSIS/: system_TMPM46B.c system_TMPM46B.h TMPM46B.h
  group TX04_CMSIS/startup
    ../../../../../Libraries/TX04_CMSIS/startup/iar/: startup_TMPM46B.s
  group TX04_Periph_Driver/inc
    ../../../../../Libraries/TX04_Periph_Driver/inc/: tmpm46b_fc.h tmpm46b_gpio.h tx04_common.h
  group TX04_Periph_Driver/src
    ../../../../../Libraries/TX04_Periph_Driver/src/: tmpm46b_fc.c tmpm46b_gpio.c
