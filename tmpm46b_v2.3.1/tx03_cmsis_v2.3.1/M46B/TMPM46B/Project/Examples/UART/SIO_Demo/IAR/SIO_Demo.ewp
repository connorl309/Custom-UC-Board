# IAR project SIO_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TMPM46BF10FG Toshiba TMPM46BF10FG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\..\Libraries\TX04_CMSIS; ..\..\..\..\..\Libraries\TX04_Periph_Driver\inc; ..\APP
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SIO_Demo.srec
  ILINK.IlinkOutputFile: SIO_Demo.out
  ILINK.IlinkIcfFile: ..\..\..\..\Template\IAR\TMPM46BF10FG_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\..\Libraries\TX04_CMSIS; ..\..\..\..\..\Libraries\TX04_Periph_Driver\inc; ..\APP; ..\..\..\Utilities\TMPM46B-EVAL
  group APP
    ../APP/: main.c main.h tmpm46b_sio_int.c tmpm46b_sio_int.h
  group TX04_CMSIS
    ../../../../../Libraries/TX04_CMSIS/: system_TMPM46B.c
  group TX04_CMSIS/startup
    ../../../../../Libraries/TX04_CMSIS/startup/iar/: startup_TMPM46B.s
  group TX04_Periph_Driver/inc
    ../../../../../Libraries/TX04_Periph_Driver/inc/: tmpm46b_uart.h
  group TX04_Periph_Driver/src
    ../../../../../Libraries/TX04_Periph_Driver/src/: tmpm46b_uart.c
