# IAR project UART_Retarget.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TMPM46BF10FG Toshiba TMPM46BF10FG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG
  ICCARM.CCIncludePath2: ..\APP; ..\..\..\..\..\Libraries\TX04_CMSIS\; ..\..\..\..\..\Libraries\TX04_Periph_Driver\inc; ..\..\..\Utilities\TMPM46B-EVAL
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: UART_Retarget.srec
  ILINK.IlinkOutputFile: UART_Retarget.out
  ILINK.IlinkIcfFile: ..\..\..\..\Template\IAR\TMPM46BF10FG_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group APP
    ../APP/: main.c main.h retarget.c tmpm46b_uart_int.c tmpm46b_uart_int.h uart.c uart.h
  group TMPM46B-EVAL
    ../../../Utilities/TMPM46B-EVAL/: led.c led.h sw.c sw.h
  group TX04_CMSIS
    ../../../../../Libraries/TX04_CMSIS/: system_TMPM46B.c
  group TX04_CMSIS/startup
    ../../../../../Libraries/TX04_CMSIS/startup/iar/: startup_TMPM46B.s
  group TX04_Periph_Driver/inc
    ../../../../../Libraries/TX04_Periph_Driver/inc/: tmpm46b_gpio.h tmpm46b_uart.h
  group TX04_Periph_Driver/src
    ../../../../../Libraries/TX04_Periph_Driver/src/: tmpm46b_gpio.c tmpm46b_uart.c
