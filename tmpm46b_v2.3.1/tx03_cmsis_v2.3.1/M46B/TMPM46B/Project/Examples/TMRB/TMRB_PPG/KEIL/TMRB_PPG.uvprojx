# Keil uVision project TMRB_PPG.uvprojx, settings and files
target TMRB_PPG (ARM-ADS)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: TMRB_PPG
  c flags: Optim=3
  c define: DEBUG
  c include: ..\..\..\..\..\Libraries\TX04_CMSIS;..\..\..\..\..\Libraries\TX04_Periph_Driver\inc;..\..\..\Utilities\TMPM46B-EVAL
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\Template\KEIL\tmpm46bf10.sct
  group APP
    ../APP/: main.c tmrb_leadingtimingdisplay.c
  group TX04_CMSIS
    ../../../../../Libraries/TX04_CMSIS/: system_TMPM46B.c
    ../../../../../Libraries/TX04_CMSIS/startup/arm/: startup_TMPM46B.s
  group TX04_Periph_Driver
    ../../../../../Libraries/TX04_Periph_Driver/src/: tmpm46b_gpio.c tmpm46b_tmrb.c tmpm46b_uart.c
  group TMPM46B-EVAL
    ../../../Utilities/TMPM46B-EVAL/: sw.c common_uart.c
software components: CMSIS:CORE 3.40.0
