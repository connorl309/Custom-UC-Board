# Keil uVision project FUART_LoopBack.uvprojx, settings and files
target FUART_LoopBack (ARM-ADS)
  device: TMPM46BF10FG Toshiba
  pack: Keil.TMPM4_DFP.1.1.2
  cpu: IROM(0x00000000,0x180000) IRAM(0x20000000,0x30000) IRAM2(0x20030000,0x00400) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FUART_LoopBack
  c flags: Optim=3
  c include: ..\..\..\..\..\Libraries\TX04_CMSIS;..\..\..\..\..\Libraries\TX04_Periph_Driver\inc;..\..\..\Utilities\TMPM46B-EVAL
  memory RVCT4: ROM 0x0 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x20030000 size 0x400
  scatter file: ..\..\..\..\Template\KEIL\tmpm46bf10.sct
  group APP
    ../APP/: main.c
  group TX04_CMSIS
    ../../../../../Libraries/TX04_CMSIS/: system_TMPM46B.c
    ../../../../../Libraries/TX04_CMSIS/startup/arm/: startup_TMPM46B.s
  group TX04_Periph_Driver
    ../../../../../Libraries/TX04_Periph_Driver/src/: tmpm46b_fuart.c tmpm46b_gpio.c tmpm46b_uart.c
  group TMPM46B-EVAL
    ../../../Utilities/TMPM46B-EVAL/: sw.c common_uart.c led.c
software components: CMSIS:CORE 3.40.0, CMSIS:DSP 1.4.2
