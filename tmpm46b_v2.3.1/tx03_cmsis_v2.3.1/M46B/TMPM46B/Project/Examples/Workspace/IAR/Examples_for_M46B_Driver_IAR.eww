<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\ADC\ADC_DEMO\IAR\ADC_Demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\AES\AES_CBC\IAR\AES_CBC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\AES\AES_CTR\IAR\AES_CTR.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\AES\AES_ECB\IAR\AES_ECB.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\CG\CG_Idle\IAR\CG_Idle.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\CG\CG_ModeSwitch\IAR\CG_ModeSwitch.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\CG\CG_Stop2\IAR\CG_Stop2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\FC\DemoA\IAR\DemoA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\FC\DemoB\IAR\DemoB.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\ESG\ESG_Demo\IAR\ESG_Demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\EXB\EXB_Demo\IAR\EXB_Demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\FC\Flash_Swp_A\IAR\Flash_Swp_A.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\FC\Flash_Swp_B\IAR\Flash_Swp_B.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\FC\Flash_Userboot\IAR\Flash_Userboot.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\FUART\FUART_LoopBack\IAR\FUART_LoopBack.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\GPIO\GPIO_LED\IAR\GPIO_LED.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\I2C\I2C_SLAVE\IAR\I2C_SLAVE.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\IGBT\IGBT_OnePPG\IAR\IGBT_OnePPG.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\IGBT\IGBT_TwoPPG\IAR\IGBT_TwoPPG.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\LVD\LVD_DEMO\IAR\LVD_DEMO.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\MLA\MLA_ADD\IAR\MLA_ADD.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\MLA\MLA_MUL\IAR\MLA_MUL.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\MLA\MLA_SUB\IAR\MLA_SUB.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\RTC\RTC_Basic\IAR\RTC_Basic.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\SHA\SHA_Demo\IAR\SHA_Demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\SSP\SSP_LoopBack\IAR\SSP_LoopBack.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\TMRB\TMRB_PPG\IAR\TMRB_PPG.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\TMRB\TMRB_TIMER\IAR\TMRB_TIMER.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\UART\SIO_Demo\IAR\SIO_Demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\UART\UART_FIFO_Demo\IAR\UART_FIFO_Demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\UART\UART_Retarget\IAR\UART_Retarget.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\uDMAC\uDMAC_Demo\IAR\uDMAC_Demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\WDT\WDT_NMI\IAR\WDT_NMI.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build All</name>
      <member>
        <project>ADC_Demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>ADC_Demo</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>AES_CBC</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>AES_CBC</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>AES_CTR</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>AES_CTR</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>AES_ECB</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>AES_ECB</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>CG_Idle</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>CG_Idle</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>CG_ModeSwitch</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>CG_ModeSwitch</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>CG_Stop2</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>CG_Stop2</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>ESG_Demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>ESG_Demo</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>EXB_Demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>EXB_Demo</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>FUART_LoopBack</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>FUART_LoopBack</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>GPIO_LED</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>GPIO_LED</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>I2C_SLAVE</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>I2C_SLAVE</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>IGBT_OnePPG</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>IGBT_OnePPG</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>IGBT_TwoPPG</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>IGBT_TwoPPG</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>LVD_DEMO</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>LVD_DEMO</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>MLA_ADD</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>MLA_ADD</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>MLA_MUL</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>MLA_MUL</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>MLA_SUB</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>MLA_SUB</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>RTC_Basic</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>RTC_Basic</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>SHA_Demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>SHA_Demo</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>SIO_Demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>SIO_Demo</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>SSP_LoopBack</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>SSP_LoopBack</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>TMRB_PPG</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TMRB_PPG</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>TMRB_TIMER</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TMRB_TIMER</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>UART_FIFO_Demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>UART_FIFO_Demo</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>UART_Retarget</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>UART_Retarget</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>uDMAC_Demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>uDMAC_Demo</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>WDT_NMI</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>WDT_NMI</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>DemoA</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>DemoA</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>DemoB</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>DemoB</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>Flash_Swp_A</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>Flash_Swp_A</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>Flash_Swp_B</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>Flash_Swp_B</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>Flash_Userboot</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>Flash_Userboot</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


