# IAR project Template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TMPM46BF10FG Toshiba TMPM46BF10FG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG
  ICCARM.CCIncludePath2: ..\APP; ..\..\..\Libraries\TX04_CMSIS; ..\..\..\Libraries\TX04_Periph_Driver\inc; ..\Utilities\TMPM46BEVAL
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.srec
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkIcfFile: TMPM46BF10FG_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\APP; ..\..\..\Libraries\TX04_CMSIS; ..\..\..\Libraries\TX04_Periph_Driver\inc; ..\Utilities\TMPM440EVAL
  group APP
    ../APP/: main.c
  group TX04_CMSIS
    ../../../Libraries/TX04_CMSIS/: system_TMPM46B.c system_TMPM46B.h TMPM46B.h
  group TX04_CMSIS/startup
    ../../../Libraries/TX04_CMSIS/startup/iar/: startup_TMPM46B.s
  group TX04_Periph_Driver/inc
    ../../../Libraries/TX04_Periph_Driver/inc/: tmpm46b_adc.h tmpm46b_aes.h tmpm46b_cg.h tmpm46b_esg.h tmpm46b_exb.h tmpm46b_fc.h tmpm46b_fuart.h tmpm46b_gpio.h tmpm46b_i2c.h tmpm46b_igbt.h tmpm46b_lvd.h tmpm46b_mla.h tmpm46b_rtc.h tmpm46b_sha.h tmpm46b_ssp.h tmpm46b_tmrb.h tmpm46b_uart.h tmpm46b_udmac.h tmpm46b_wdt.h tx04_common.h
  group TX04_Periph_Driver/src
    ../../../Libraries/TX04_Periph_Driver/src/: tmpm46b_adc.c tmpm46b_aes.c tmpm46b_cg.c tmpm46b_esg.c tmpm46b_exb.c tmpm46b_fc.c tmpm46b_fuart.c tmpm46b_gpio.c tmpm46b_i2c.c tmpm46b_igbt.c tmpm46b_lvd.c tmpm46b_mla.c tmpm46b_rtc.c tmpm46b_sha.c tmpm46b_ssp.c tmpm46b_tmrb.c tmpm46b_uart.c tmpm46b_udmac.c tmpm46b_wdt.c
