# Keil uVision project project.uvprojx, settings and files
target PROJECT (ARM-ADS)
  device: TMPM46BF10FG Toshiba
  pack: Keil.TMPM4_DFP.1.1.2
  cpu: IROM(0x00000000,0x180000) IRAM(0x20000000,0x30000) IRAM2(0x20030000,0x00400) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=3
  c include: ..\..\..\Libraries\TX04_CMSIS;..\..\..\Libraries\TX04_Periph_Driver\inc;..\..\Examples\Utilities
  memory RVCT4: ROM 0x0 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x20030000 size 0x400
  scatter file: .\tmpm46bf10.sct
  group App
    ../APP/: main.c
  group TX04_CMSIS
    ../../../Libraries/TX04_CMSIS/: system_TMPM46B.c
    ../../../Libraries/TX04_CMSIS/startup/arm/: startup_TMPM46B.s
  group TX04_Periph_Driver
    ../../../Libraries/TX04_Periph_Driver/inc/: tx04_common.h
software components: CMSIS:CORE 3.40.0
